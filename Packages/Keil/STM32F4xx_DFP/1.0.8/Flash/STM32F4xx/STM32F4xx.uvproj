# Keil uVision project STM32F4xx.uvproj, settings and files
target STM32F4xx_128 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: STM32F4xx_128
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: FLASH_MEM STM32F4xx_128
  c include: .\..
  asm include: .\..
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target STM32F4xx_256 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: STM32F4xx_256
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: FLASH_MEM STM32F4xx_256
  c include: .\..
  asm include: .\..
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32F4xx_384 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: STM32F4xx_384
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: FLASH_MEM STM32F4xx_384
  c include: .\..
  asm include: .\..
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32F4xx_512 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: STM32F4xx_512
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: FLASH_MEM STM32F4xx_512
  c include: .\..
  asm include: .\..
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32F4xx_1024 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: STM32F4xx_1024
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: FLASH_MEM STM32F4xx_1024
  c include: .\..
  asm include: .\..
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32F4xx_2048 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: STM32F4xx_2048
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: FLASH_MEM STM32F4xx_2048
  c include: .\..
  asm include: .\..
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32F401xx_OPT (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: STM32F401xx_OPT
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: FLASH_OPT STM32F401xx
  c include: .\..
  asm include: .\..
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32F40xxx_41xxx_OPT (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: STM32F40xxx_41xxx_OPT
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: FLASH_OPT STM32F40xxx_41xxx
  c include: .\..
  asm include: .\..
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32F42xxx_43xxx_OPT (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: STM32F42xxx_43xxx_OPT
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: FLASH_OPT STM32F42xxx_43xxx
  c include: .\..
  asm include: .\..
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32F4xx_OPT (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: STM32F4xx_OPT
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: FLASH_OPT
  c include: .\..
  asm include: .\..
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32F4xx_OTP (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: STM32F4xx_OTP
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: FLASH_OTP
  c include: .\..
  asm include: .\..
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
