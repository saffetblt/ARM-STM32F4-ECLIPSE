# Keil uVision project GUIDemo.uvprojx, settings and files
target MCBSTM32F400 (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: GUIDemo
  c flags: Optim=4
  c define: PREMAIN_FSMC_SETUP JOYSTICK_ROTATE
  c misc: --diag_suppress=1035
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x68000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: GUIDemo.sct
  group Source
    ./: main.c
  group Documentation
    ./: Abstract.txt
  group ::Board Support
    C:/MDK510_ORG/ARM/PACK/Keil/STM32F4xx_DFP/1.0.7/Boards/Keil/MCBSTM32F400/Common/: Joystick_STMPE811.c LCD_X_16bitIF_STM32F4xx.c Touch_STMPE811.c
  group ::CMSIS
    RTE/CMSIS/: RTX_Conf_CM.c
    C:/MDK510_ORG/ARM/PACK/ARM/CMSIS/3.20.4/CMSIS_RTX/Lib/ARM/: RTX_CM4.lib
  group ::Device
    RTE/Device/STM32F407IG/: RTE_Device.h system_stm32f4xx.c startup_stm32f40_41xxx.s
    C:/MDK510_ORG/ARM/PACK/Keil/STM32F4xx_DFP/1.0.7/RTE_Driver/: DMA_STM32F4xx.c FSMC_STM32F4xx.c GPIO_STM32F4xx.c
  group ::Drivers
    C:/MDK510_ORG/ARM/PACK/Keil/STM32F4xx_DFP/1.0.7/RTE_Driver/: I2C_STM32F4xx.c
  group ::Graphics
    RTE/Graphics/: GUIConf.c LCDConf_MCBQVGA_LG.c
    C:/MDK510_ORG/ARM/PACK/Keil/MDK-Middleware/5.1.5/emWin/Lib/ARM/: GUI_CM4F_L.lib
    C:/MDK510_ORG/ARM/PACK/Keil/MDK-Middleware/5.1.5/emWin/Sample/Application/GUIDemo/: GUIDEMO.c GUIDEMO_AntialiasedText.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_Intro.c GUIDEMO_ListView.c GUIDEMO_RadialMenu.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_Start.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_WashingMachine.c
    C:/MDK510_ORG/ARM/PACK/Keil/MDK-Middleware/5.1.5/emWin/Sample/GUI_X/: GUI_X_Joystick.c GUI_X_RTE.c GUI_X_Touch.c
software components: CMSIS:CORE 3.20.0, CMSIS:RTOS:Keil RTX 4.74.0, Board Support:MCBSTM32F400:Joystick 1.0.0, Board Support:MCBSTM32F400:Touchscreen 1.0.0, Board Support:MCBSTM32F400:emWin LCD 1.0.0, Device:DMA 1.0.0, Device:FSMC 1.0.0, Device:GPIO 1.0.0, Device:Startup 1.3.0, Drivers:I2C 1.01.0, Graphics:CORE 5.22.1, Graphics:Demo:AntialiasedText 5.22.1, Graphics:Demo:Automotive 5.22.1, Graphics:Demo:BarGraph 5.22.1, Graphics:Demo:Bitmap 5.22.1, Graphics:Demo:ColorBar 5.22.1, Graphics:Demo:Cursor 5.22.1, Graphics:Demo:Fading 5.22.1, Graphics:Demo:Framework 5.22.1, Graphics:Demo:Graph 5.22.1, Graphics:Demo:IconView 5.22.1, Graphics:Demo:ListView 5.22.1, Graphics:Demo:RadialMenu 5.22.1, Graphics:Demo:Skinning 5.22.1, Graphics:Demo:Speed 5.22.1, Graphics:Demo:Speedometer 5.22.1, Graphics:Demo:TransparentDialog 5.22.1, Graphics:Demo:Treeview 5.22.1, Graphics:Demo:WashingMachine 5.22.1, Graphics:Display:MCBQVGA_LG 5.22.1, Graphics:Input Device:Joystick 5.22.1, Graphics:Input Device:Touchscreen 5.22.1
