# Keil uVision project Example.uvprojx, settings and files
target MCBSTM32F400 (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: Example
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source
    ./: main.c
  group Documentation
    ./: Abstract.txt
  group ::Board Support
    C:/MDK510_ORG/ARM/PACK/Keil/STM32F4xx_DFP/1.0.7/Boards/Keil/MCBSTM32F400/Common/: LCD_X_16bitIF_STM32F4xx.c
  group ::CMSIS
    RTE/CMSIS/: RTX_Conf_CM.c
    C:/MDK510_ORG/ARM/PACK/ARM/CMSIS/3.20.4/CMSIS_RTX/Lib/ARM/: RTX_CM4.lib
  group ::Device
    RTE/Device/STM32F407IG/: RTE_Device.h system_stm32f4xx.c startup_stm32f40_41xxx.s
  group ::Graphics
    RTE/Graphics/: GUIConf.c LCDConf_MCBQVGA_LG.c
    C:/MDK510_ORG/ARM/PACK/Keil/MDK-Middleware/5.1.5/emWin/Lib/ARM/: GUI_CM4F_L.lib
    C:/MDK510_ORG/ARM/PACK/Keil/MDK-Middleware/5.1.5/emWin/Sample/GUI_X/: GUI_X_RTE.c
software components: CMSIS:CORE 3.20.0, CMSIS:RTOS:Keil RTX 4.74.0, Board Support:MCBSTM32F400:emWin LCD 1.0.0, Device:Startup 1.3.0, Graphics:CORE 5.22.1, Graphics:Display:MCBQVGA_LG 5.22.1
