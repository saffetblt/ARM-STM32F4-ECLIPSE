# Keil uVision project Demo.uvprojx, settings and files
target STM32F407 MDK-Lite (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: Demo
  c flags: Optim=4
  c define: _EVAL_VERSION_
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Graphics
    ./: Arrows_16bpp_red.c Button_16bpp.c Bulb_16bpp.c
  group Source Files
    ./: Demo.c
  group Documentation
    ./: Abstract.txt
  group ::Board Support
    C:/MDK510_ORG/ARM/PACK/Keil/STM32F4xx_DFP/1.0.7/Boards/Keil/MCBSTM32F400/Common/: ADC.c Accel_LIS3DH.c Camera_OVM7690.c GLCD_16bitIF_STM32F4xx.c Gyroscope_L3G4200D.c Joystick_STMPE811.c Keyboard.c LED.c Touch_STMPE811.c
  group ::CMSIS
    RTE/CMSIS/: RTX_Conf_CM.c
    C:/MDK510_ORG/ARM/PACK/ARM/CMSIS/3.20.4/CMSIS_RTX/Lib/ARM/: RTX_CM4.lib
  group ::Device
    RTE/Device/STM32F407IG/: RTE_Device.h system_stm32f4xx.c startup_stm32f40_41xxx.s
    C:/MDK510_ORG/ARM/PACK/Keil/STM32F4xx_DFP/1.0.7/RTE_Driver/: DMA_STM32F4xx.c GPIO_STM32F4xx.c
  group ::Drivers
    C:/MDK510_ORG/ARM/PACK/Keil/STM32F4xx_DFP/1.0.7/RTE_Driver/: I2C_STM32F4xx.c
target STM32F407 Flash (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: as above
  output: Demo
  c flags: Optim=4
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 3.20.0, CMSIS:RTOS:Keil RTX 4.74.0, Board Support:MCBSTM32F400:A/D Converter 1.0.0, Board Support:MCBSTM32F400:Accelerometer 1.0.0, Board Support:MCBSTM32F400:Camera 1.0.0, Board Support:MCBSTM32F400:Graphic LCD 1.0.0, Board Support:MCBSTM32F400:Gyroscope 1.0.0, Board Support:MCBSTM32F400:Joystick 1.0.0, Board Support:MCBSTM32F400:Keyboard 1.0.0, Board Support:MCBSTM32F400:LED 1.0.0, Board Support:MCBSTM32F400:Touchscreen 1.0.0, Device:DMA 1.0.0, Device:GPIO 1.0.0, Device:Startup 1.3.0, Drivers:I2C 1.01.0
