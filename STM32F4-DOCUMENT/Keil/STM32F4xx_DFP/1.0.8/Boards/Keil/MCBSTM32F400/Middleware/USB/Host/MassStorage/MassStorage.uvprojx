# Keil uVision project MassStorage.uvprojx, settings and files
target STM32F407 Flash (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: MassStorage
  c flags: Optim=4 OneElfS=1
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source
    ./: MassStorage.c Getline.c
  group Documentation
    ./: Abstract.txt
  group ::Board Support
    C:/MDK510_ORG/ARM/PACK/Keil/STM32F4xx_DFP/1.0.7/Boards/Keil/MCBSTM32F400/Common/: GLCD_16bitIF_STM32F4xx.c
  group ::CMSIS
    RTE/CMSIS/: RTX_Conf_CM.c
    C:/MDK510_ORG/ARM/PACK/ARM/CMSIS/3.20.4/CMSIS_RTX/Lib/ARM/: RTX_CM4.lib
  group ::Device
    RTE/Device/STM32F407IG/: RTE_Device.h system_stm32f4xx.c startup_stm32f40_41xxx.s
    C:/MDK510_ORG/ARM/PACK/Keil/STM32F4xx_DFP/1.0.7/RTE_Driver/: GPIO_STM32F4xx.c
  group ::Drivers
    C:/MDK510_ORG/ARM/PACK/Keil/STM32F4xx_DFP/1.0.7/RTE_Driver/: OTG_FS_STM32F4xx.c OTG_HS_STM32F4xx.c USBH_FS_STM32F4xx.c USBH_HS_STM32F4xx.c
  group ::File System
    RTE/File_System/: FS_Config.c FS_Config_USB_0.h FS_Config_USB_1.h
    C:/MDK510_ORG/ARM/PACK/Keil/MDK-Middleware/5.1.5/FileSystem/Lib/ARM/: FS_LFN_CM3_L.lib
  group ::USB
    RTE/USB/: USBH_Config_0.c USBH_Config_1.c USBH_Config_MSC.h
    C:/MDK510_ORG/ARM/PACK/Keil/MDK-Middleware/5.1.5/USB/Lib/ARM/: USB_CM3_L.lib
software components: CMSIS:CORE 3.20.0, CMSIS:RTOS:Keil RTX 4.74.0, Board Support:MCBSTM32F400:Graphic LCD 1.0.0, File System:CORE 5.0.4, File System:Drive:USB 5.0.4, USB:CORE 5.0.4, USB:Host 5.0.4, USB:Host:MSC 5.0.4, Device:GPIO 1.0.0, Device:Startup 1.3.0, Drivers:USB Host:Full-speed 1.03.0, Drivers:USB Host:High-speed 1.03.0
