# Keil uVision project FTP_Server.uvprojx, settings and files
target STM32F407 Flash (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: FTP_Server
  c flags: Optim=4
  c misc: --diag_suppress=C4017
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source
    ./: FTP_Server.c
  group Documentation
    ./: Abstract.txt
  group ::Board Support
    C:/MDK510_ORG/ARM/PACK/Keil/STM32F4xx_DFP/1.0.7/Boards/Keil/MCBSTM32F400/Common/: GLCD_16bitIF_STM32F4xx.c LED.c
  group ::CMSIS
    RTE/CMSIS/: RTX_Conf_CM.c
    C:/MDK510_ORG/ARM/PACK/ARM/CMSIS/3.20.4/CMSIS_RTX/Lib/ARM/: RTX_CM4.lib
  group ::Device
    RTE/Device/STM32F407IG/: RTE_Device.h system_stm32f4xx.c startup_stm32f40_41xxx.s
    C:/MDK510_ORG/ARM/PACK/Keil/STM32F4xx_DFP/1.0.7/RTE_Driver/: DMA_STM32F4xx.c GPIO_STM32F4xx.c
  group ::Drivers
    C:/MDK510_ORG/ARM/PACK/Keil/MDK-Middleware/5.1.5/Network/Driver/: PHY_ST802RT1.c
    C:/MDK510_ORG/ARM/PACK/Keil/STM32F4xx_DFP/1.0.7/RTE_Driver/: EMAC_STM32F4xx.c MCI_STM32F4xx.c
  group ::File System
    RTE/File_System/: FS_Config.c FS_Config_MC_0.h
    C:/MDK510_ORG/ARM/PACK/Keil/MDK-Middleware/5.1.5/FileSystem/Lib/ARM/: FS_LFN_CM3_L.lib
  group ::Network
    RTE/Network/: Net_Config.c Net_Config_ETH_0.h Net_Config_FTP_Server.h Net_Config_TCP.h Net_Config_UDP.h
    C:/MDK510_ORG/ARM/PACK/Keil/MDK-Middleware/5.1.5/Network/Interface/: FTP_Server_FS.c
    C:/MDK510_ORG/ARM/PACK/Keil/MDK-Middleware/5.1.5/Network/Lib/ARM/: Net_CM3_L.lib
software components: CMSIS:CORE 3.20.0, CMSIS:RTOS:Keil RTX 4.74.0, Board Support:MCBSTM32F400:Graphic LCD 1.0.0, Board Support:MCBSTM32F400:LED 1.0.0, File System:CORE 5.0.4, File System:Drive:Memory Card 5.0.4, Network:CORE 5.0.4, Network:Interface:ETH 5.0.4, Network:Service:FTP Server 5.0.4, Network:Socket:TCP 5.0.4, Network:Socket:UDP 5.0.4, Device:DMA 1.0.0, Device:GPIO 1.0.0, Device:Startup 1.3.0, Drivers:Ethernet MAC 1.02.0, Drivers:Ethernet PHY:ST802RT1 5.01.0, Drivers:MCI 1.01.0
